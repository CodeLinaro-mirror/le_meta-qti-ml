# List of packages installed onto the root file system.
include ${BASEMACHINE}/${BASEMACHINE}-ml-image.inc
